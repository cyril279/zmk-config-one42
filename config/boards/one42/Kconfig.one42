## config/boards/one42/Kconfig.one42
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: Apache-2.0

config BOARD_ONE42
	select SOC_NRF52840_QIAA
```
